# Keil uVision project Lab3.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT
  c include: C:\ti\TivaWare_C_Series-2.1.4.178\driverlib;C:\ti\TivaWare_C_Series-2.1.4.178
  asm include: C:\ti\TivaWare_C_Series-2.1.4.178\driverlib;C:\ti\TivaWare_C_Series-2.1.4.178\driverlib\rvmdk
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: tm4c123gh6pm.h main.c
  group library
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.4.3, RTOS:Core 10.4.3, RTOS:Heap 10.4.3, CMSIS:CORE 5.5.0, Device:Startup 1.0.1
